# Keil uVision project 遥控小车.uvproj, settings and files
target Target 1 (MCS-251)
  device: STC32F12K54 Series STC
  cpu: IRAM(0-0x1FFF) XRAM(0x10000-0x10FFF) IROM(0xFF0000-0xFFFFFF) CLOCK(35000000)
  output: 遥控小车 +hex
  link misc: REMOVEUNUSED
  group Source Group 1
    ./: main.c STC32_FPMU_LARGE_V1.0.LIB STC32_MDU32_LARGE_V1.1.LIB
    ./User_Group/: uart.c pid.c can.c bno08x.c
    ../遥控小车/User_Group/: spi.c
